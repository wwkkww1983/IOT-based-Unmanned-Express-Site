# Keil uVision project servor.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: servor +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CORE;.\FWlib\inc;.\HARDWARE\Timer;.\HARDWARE\Servo;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\PS2;.\HARDWARE\SPI;.\HARDWARE\FLASH;.\HARDWARE\Common;.\HARDWARE\Oneline;.\HARDWARE\Beep;.\HARDWARE\Adc;.\HARDWARE\Sensor
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./HARDWARE/Servo/: servor.c
    ./HARDWARE/Timer/: timer.c
    ./HARDWARE/PS2/: Ps2.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/FLASH/: flash.c
    ./HARDWARE/Common/: common.c
    ./HARDWARE/Oneline/: oneline.c
    ./HARDWARE/Beep/: beep.c
    ./HARDWARE/Adc/: Adc.c
    ./HARDWARE/Sensor/: Sensor.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
